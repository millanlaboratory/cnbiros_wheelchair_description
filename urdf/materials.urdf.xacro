Commit message: New wheelchair model - Missing sensors

File: urdf/materials.urdf.xacro (robot description, xacro)
@@ -10,3 +10,6 @@
 		<color rgba="0 1 0 1"/>
 	</material>
+	<material name="darkgrey">
+		<color rgba="0.22 0.22 0.22 1"/>
+	</material>
 </robot>
